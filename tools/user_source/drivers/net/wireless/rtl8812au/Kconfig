## tools/user_source/drivers/net/wireless/rtl8812au/Kconfig
```kconfig
config RTL8812AU
	tristate "Realtek 8812A USB WiFi"
	help
	  Help message of RTL8812AU
```
